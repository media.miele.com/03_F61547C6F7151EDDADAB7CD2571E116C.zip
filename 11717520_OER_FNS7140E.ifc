Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [COBie2.4DesignDeliverable]
File name: 0001
Time: 2022-07-19T07:42:46
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 21.1.21.45 - Exporter 21.1.21.45 - Default UI
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Tue Jul 19 07:42:46 2022 * Host: DEGTW9512 * Database: C:\Users\deschvi\AppData\Local\Temp\467efac7-2a30-4bbe-ac65-42dc2e83f97d\f37eb41e-3725-45f5-887a-c392d814f927\ifc * Database version: 5507 * Database creation date: Tue Jul 19 07:42:42 2022 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Tue Jul 19 07:42:42 2022 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Tue Jul 19 07:42:42 2022 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, 0001
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 21, 31, 181945; RefLongitude: -71, -3, -24, -263305; RefElevation: 0 mm
Pset_ProductRequirements - Category: Project Information

# IfcBuildingElementProxy: 11717520_OER_FNS7140E:37714000_OER_11717520_FNS7140E, (2)
In: Default
Type - Material: z_Miele_Design_Steel_Chrom
Type - Pset_BuildingElementProxyCommon - Reference: 37714000_OER_11717520_FNS7140E
Type - Pset_ManufacturerTypeInformation - Manufacturer: Miele
Type - Pset_ProductRequirements - Category: Specialty Equipment
Type - Pset_QuantityTakeOff - Reference: 37714000_OER_11717520_FNS7140E
Type - Pset_ProvisionForVoid - Width: 559 mm; Height: 872 mm; Depth: 544 mm
Material: z_Miele_Design_Steel_Chrom, z_Miele_Design_BRWS, z_Miele_Design_Glass Black, z_Miele_Design_Zinc_Steel, z_Miele_Connection_Electric
Pset_BuildingElementProxyCommon - sets with these values: 2

# IfcDistributionPort, Port_353594
Description: Flow; FlowDirection: SOURCEANDSINK
